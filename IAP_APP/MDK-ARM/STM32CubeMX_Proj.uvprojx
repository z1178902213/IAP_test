# Keil uVision project STM32CubeMX_Proj.uvprojx, settings and files
target STM32CubeMX_Proj (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: STM32CubeMX_Proj +hex
  AfterMake: .\User_Format.bat
  AfterMake: fromelf --bin --output .\STM32CubeMX_Proj\STM32CubeMX_Proj.bin .\STM32CubeMX_Proj\STM32CubeMX_Proj.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Middlewares/Third_Party/LwIP/src/include/;../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../FreeRTOS/Include;../Middlewares/Third_Party/LwIP/system;../Middlewares/Third_Party/LwIP/system/arch;../BSP/Inc;../Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8040000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: user_task.c user_hal_callback.c main.c stm32f4xx_it.c stm32f4xx_hal_msp.c ethernetif.c
    ../FreeRTOS/Source/: cmsis_os.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_eth.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group FreeRTOS/Source
    ../FreeRTOS/Source/: croutine.c event_groups.c heap_4.c list.c port.c queue.c stream_buffer.c tasks.c timers.c
  group BSP
    ../BSP/Src/: bsp_led.c bsp_console.c bsp_wifi.c LAN8720A.c bsp_eth.c
  group Middlewares/LwIP/Core/IPv4
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: autoip.c igmp.c ip4_frag.c ip4_addr.c ip4.c etharp.c dhcp.c icmp.c
  group Middlewares/LwIP/Api
    ../Middlewares/Third_Party/LwIP/src/api/: api_lib.c netdb.c netifapi.c err.c sockets.c netbuf.c api_msg.c tcpip.c
  group Middlewares/LwIP/Netif
    ../Middlewares/Third_Party/LwIP/src/netif/: ethernet.c
  group Middlewares/LwIP/Core
    ../Middlewares/Third_Party/LwIP/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
software components: CMSIS:CORE 4.3.0
