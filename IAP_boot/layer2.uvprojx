# Keil uVision project layer2.uvprojx, settings and files
target Target_1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: layer2 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT5: ROM 0x8040000 size 0xc0000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group MDK-ARM
    ./Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
  group User
    ./: main.c bsp_led.c bsp_led.h bsp_uart.c bsp_uart.h bsp_spi.c bsp_spi.h app.c iflash.c iflash.h app.h app2.c app2.h loader.c loader.h
  group Driver
    ./: user_rcc.c user_gpio.c user_uart.c user_spi.c user_rcc.h user_gpio.h user_uart.h user_spi.h stm32f4xx.h
